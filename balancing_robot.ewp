# IAR project balancing_robot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\StellarisWare\third_party\SafeRTOS; C:\StellarisWare\inc; C:\StellarisWare\driverlib; .; ..; ..\..; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party; ..\..\..\utils
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4; ..\..\..\third_party; ..\..\..\utils
  OBJCOPY.OOCOutputFile: balancing_robot.bin
  ILINK.IlinkOutputFile: safertos_demo.out
  ILINK.IlinkIcfFile: balancing_robot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Headers
    ./: adxl345.h command_handler.h i2ctools.h kalman.h l3g4200d.h motor.h my_timers.h my_uart.h pid.h softeeprom.h
  group Libraries
    ../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ./: adxl345.c command_handler.c i2ctools.c kalman.c l3g4200d.c main.c motor.c my_timers.c my_uart.c pid.c softeeprom.c startup.c
    ../../../utils/: uartstdio.c
